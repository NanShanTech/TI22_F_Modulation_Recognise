# Keil uVision project h743_hal.uvprojx, settings and files
target h743_hal (6160000::V6.16::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: h743_hal +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7, __FPU_PRESENT=1
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Hardware;../Drivers/CMSIS/DSP/Include;../App;../App/comm;../App/dac;../App/dds;../App/fft;../App/measure;../App/task;../App/utils;../long_fft;../App/dsp;../App/adc;../App/demodulation
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\h743_hal\h743_hal.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group APP
    ../App/: app_config.h app_types.h app.h
  group long_fft
    ../long_fft/: arm_bitreversal2_extra.c arm_cfft_f32_extra.c arm_cfft_init_f32_extra.c arm_common_tables_extra.c arm_common_tables_extra.h arm_const_structs_extra.c arm_const_structs_extra.h arm_cortexM7l_math.lib arm_rfft_fast_f32_extra.c arm_rfft_fast_init_f32_extra.c extra_ffts.h
  group MyDrive
    ../App/adc/: ad9220.c ad9220.h
    ../App/dds/: ad9910.c ad9910.h ad9959.c ad9959.h
    ../App/utils/: delay.c delay.h
    ../App/comm/: serial.c serial.h
  group Task
    ../App/measure/: freq_measure.c freq_measure.h
    ../App/task/: adc_task.c adc_task.h scheduler.c scheduler.h tasks.c tasks.h
  group fft
    ../App/fft/: fft_analyzer.c fft_analyzer.h
  group my_dsp
    ../App/dsp/: dsp_adaptive.c dsp_adaptive.h dsp_analyze.c dsp_analyze.h dsp_filter.c dsp_filter.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 5.5.0
